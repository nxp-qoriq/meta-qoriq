do_compile() {
   oe_runmake
}
