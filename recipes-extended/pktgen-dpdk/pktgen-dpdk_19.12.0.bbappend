export RTE_SDK = "${RECIPE_SYSROOT}${datadir}/dpdk"
EXTRA_OEMAKE += 'RTE_SDK="${RECIPE_SYSROOT}${datadir}/dpdk"'
