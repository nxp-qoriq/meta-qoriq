# Copyright 2022-2023 NXP
require optee-client-qoriq.inc

OPTEE_CLIENT_BRANCH = "lf-6.1.1_1.0.0"
PV:append = "+git${SRCPV}"
