SRC_URI = "git://github.com/qoriq-open-source/ptpd.git;nobranch=1 \
           file://ptpd-use-pkgconfig.patch \
"
SRCREV = "ec34cdd10446619d036ac8d6a86b8276f0d4a81c"

S = "${WORKDIR}/git"

