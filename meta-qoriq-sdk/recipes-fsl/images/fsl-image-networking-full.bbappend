IMAGE_FSTYPES:append = " tar.zst"
