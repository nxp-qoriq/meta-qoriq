SRC_URI = "git://bitbucket.sw.nxp.com/gitam/atf.git;protocol=ssh;nobranch=1"
SRCREV = "dae1e7dfe8c6ad7834a5907685f57fe73b25cce0"

rcw_ls1012a = "_default"
PLATFORM_lx2160ardb-rev2 = "lx2160ardb"
ddrphyopt_lx2160ardb-rev2 = "fip_ddr_sec"

