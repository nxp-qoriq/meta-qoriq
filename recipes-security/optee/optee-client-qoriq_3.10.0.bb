# Copyright (C) 2020 NXP
require recipes-security/optee/optee-client.nxp.inc

SRCBRANCH = "imx_3.10.y"
SRCREV = "2a77cf88d956c34cb4a1c191bea6113e327f5fe0"

COMPATIBLE_MACHINE = "(qoriq-arm64)"
