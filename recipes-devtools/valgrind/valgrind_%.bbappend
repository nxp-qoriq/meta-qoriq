SECURITY_NOPIE_CFLAGS_qoriq-ppc = ""
