ATF_VERSION = "1.5"
SRCREV = "3a1ba78d38a7801a7f1427cd6712075ae459bbeb"

include arm-trusted-firmware.inc
