LIC_FILES_CHKSUM = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9"

SRC_URI = "http://www.nxp.com/lgfiles/sdk/lsdk2004/firmware-cadence-lsdk2004.bin;fsl-eula=true"

SRC_URI[md5sum] = "d7eb8ef87cae8e4a205c266b3ac6f330"
SRC_URI[sha256sum] = "bef89a3eceed95e90748a2301d6f6ffbdf1a72237c0045093cb9485b05eb8fbd"

S = "${WORKDIR}/firmware-cadence-lsdk2004"

