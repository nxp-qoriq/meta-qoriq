LIC_FILES_CHKSUM = "file://../LICENSE;md5=751419260aa954499f7abaabaa882bbe"
SRCREV = "4ceb28e3146e4134e10a25cb404abba839de8412"
