DEPENDS = "glib-2.0 zlib pixman dtc"
