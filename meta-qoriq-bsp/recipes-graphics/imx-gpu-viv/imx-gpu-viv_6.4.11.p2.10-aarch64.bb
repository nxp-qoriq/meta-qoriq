require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837"

IMX_SRCREV_ABBREV = "06c9729"

SRC_URI[sha256sum] = "6895c051002a8b9b53f16ac1dc535217bfed36fc91d881f301ec7d28c6239973"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
