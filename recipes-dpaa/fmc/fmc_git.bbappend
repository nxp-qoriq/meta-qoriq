SRC_URI = "git://bitbucket.sw.nxp.com/scm/dpaamodules/fmc;protocol=https;nobranch=1 \
"

SRCREV = "ba9ed3b98711c44611decea72828a372b8b537e5"
