ONNXRUNTIME_SRC = "gitsm://bitbucket.sw.nxp.com/aitec/onnxruntime-imx.git;protocol=ssh"
INSANE_SKIP_${PN} += "file-rdeps"

