RDEPENDS_netcf += "libxml2"
