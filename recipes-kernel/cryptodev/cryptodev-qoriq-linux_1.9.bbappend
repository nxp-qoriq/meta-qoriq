SRC_URI = "git://source.codeaurora.org/external/qoriq/qoriq-components/cryptodev-linux;protocol=https;nobranch=1"

SRCREV = "479e6e7f071e252c0c37ea38d38fdb4cd808f496"
