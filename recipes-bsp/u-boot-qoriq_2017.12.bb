FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_qoriq_arm64 = " file://0001-Add-OTA-support.patch \
"
SRC_URI_append_qoriq_arm = " file://0001-Add-OTA-support.patch \
"
