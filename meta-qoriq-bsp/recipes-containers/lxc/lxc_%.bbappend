PACKAGECONFIG:append = " seccomp"
INSANE_SKIP:${PN}-staticdev += "buildpaths"
