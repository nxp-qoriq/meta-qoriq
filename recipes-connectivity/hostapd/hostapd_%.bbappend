FILESEXTRAPATHS:prepend:qoriq := "${THISDIR}/${PN}:"
