# Copyright 2024-2025 NXP

OPTEE_TEST_BRANCH = "lf_4.6.y"
SRCREV = "${AUTOREV}"
PV:append = "+git"
