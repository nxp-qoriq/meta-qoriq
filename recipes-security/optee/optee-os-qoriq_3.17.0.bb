# Copyright (C) 2022 NXP
require optee-os.nxp.inc

OPTEE_OS_BRANCH = "lf-5.15.32_2.0.0"
PV:append = "+git${SRCPV}"
