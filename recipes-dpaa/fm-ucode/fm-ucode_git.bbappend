LICENSE = "Freescale-Binary-EULA"
LIC_FILES_CHKSUM = "file://Freescale-Binary-EULA;md5=b784c031868ba1bd5ebc5de372c823fa"

SRC_URI = "git://github.com/nxp/qoriq-fm-ucode.git;protocol=https;nobranch=1"
SRCREV = "c275e91392e2adab1ed22f3867b8269ca3c54014"
