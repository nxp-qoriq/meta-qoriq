require secure-boot-qoriq.bb
FILESEXTRAPATHS:prepend := "${THISDIR}/secure-boot-qoriq:"
