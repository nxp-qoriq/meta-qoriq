GLIBC_64BIT_TIME_FLAGS:ls1021atwr = ""
INSANE_SKIP:ls1021atwr:append = " 32bit-time"
INSANE_SKIP:${PN}-src += " buildpaths"
