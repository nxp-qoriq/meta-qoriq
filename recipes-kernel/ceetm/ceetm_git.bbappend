SRC_URI = "git://github.com/nxp-qoriq/ceetm;protocol=https;nobranch=1"
