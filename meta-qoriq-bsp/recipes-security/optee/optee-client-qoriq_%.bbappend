# Copyright 2022-2025 NXP

OPTEE_CLIENT_BRANCH = "lf_4.6.y"
SRCREV = "${AUTOREV}"
PV:append = "+git"
