LIC_FILES_CHKSUM = "file://LICENSE;md5=c62f8109b4df15ca37ceeb5e4943626c"
SRCREV = "c89d7843943fd3bd52aa5f1ff7a91200a2f7f63b"
