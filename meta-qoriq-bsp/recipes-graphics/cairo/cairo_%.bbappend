DEPENDS:append:ls1028a = " libdrm"
