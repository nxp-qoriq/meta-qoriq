EXTRA_OECONF:append = " --enable-rsh --enable-rshd "
