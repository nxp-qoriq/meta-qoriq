PACKAGECONFIG:append:ls1028a = " egl glesv2"
PACKAGECONFIG:remove:ls1028a = "opengl"

DEPENDS:append:ls1028a = " libdrm"
