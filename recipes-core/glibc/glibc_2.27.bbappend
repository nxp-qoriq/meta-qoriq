do_install_armmultilib_append () {
       oe_multilib_header bits/floatn.h
}


