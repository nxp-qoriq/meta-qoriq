SRC_URI = "git://github.com/nxp-qoriq/fmc;nobranch=1;protocol=https"
