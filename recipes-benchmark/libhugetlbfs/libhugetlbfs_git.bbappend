FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append_e500v2 += "file://0001-Makfile-disable-link-rw.patch \
"
