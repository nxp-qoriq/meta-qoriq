# Enable allow-autospawn-for-root as default
PACKAGECONFIG_append = " autospawn-for-root"

