PLATFORM_lx2160ardb-rev2 = "lx2160ardb"
