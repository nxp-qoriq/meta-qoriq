require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"

IMX_SRCREV_ABBREV = "182a8ae"

SRC_URI[sha256sum] = "787d6b7f9d356f90b7a1e9450f0317cf665dbf5e25e25010c041cdda44f396e4"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
