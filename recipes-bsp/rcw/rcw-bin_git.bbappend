#LIC_FILES_CHKSUM = "file://LICENSE;md5=45a017ee5f4cfe64b1cddf2eb06cffc7"
SRC_URI = "git://github.com/NXP/qoriq-rcw-bin.git;protocol=https;nobranch=1"
SRCREV = "a48f3adeff3c2e54ef8b888ec629fa2d576461da"
