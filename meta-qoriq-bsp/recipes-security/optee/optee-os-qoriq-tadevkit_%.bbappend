# Copyright 2022-2025 NXP

OPTEE_OS_BRANCH = "lf_4.6.y"
SRCREV = "${AUTOREV}"
PV:append = "+git"
