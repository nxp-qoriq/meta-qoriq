SRC_URI_remove_qoriq-ppc = "file://0001-explicitly-disable-replacing-getopt.patch"
SRC_URI_remove_class-nativesdk = "file://0001-explicitly-disable-replacing-getopt.patch"
