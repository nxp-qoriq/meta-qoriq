FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append_class-native += "file://0001-support-aarch64_be.patch \
"
