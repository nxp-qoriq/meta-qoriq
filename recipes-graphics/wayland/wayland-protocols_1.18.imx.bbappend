COMPATIBLE_MACHINE = "(imxfbdev|imxgpu|qoriq-arm64)"
WAYLAND_PROTOCOLS_SRC = "git://bitbucket.sw.nxp.com/gtec/wayland-protocols-imx.git;protocol=ssh"
