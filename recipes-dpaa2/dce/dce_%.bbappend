SRC_URI = "git://source.codeaurora.org/external/qoriq/qoriq-components/dce;nobranch=1 \
      git://bitbucket.sw.nxp.com/dpaa2/qbman_userspace;protocol=ssh;nobranch=1;name=qbman;destsuffix=git/lib/qbman_userspace \
"
SRCREV = "0ec35ad12ad04b5dadfa9f8c8a718c715bde41db"
SRCREV_qbman = "2f92993a9f34e5221d6b36c63b9e30ef703e9ac3"

