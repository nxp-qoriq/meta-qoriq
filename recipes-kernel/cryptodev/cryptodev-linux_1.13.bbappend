FILESEXTRAPATHS:prepend := "${THISDIR}/cryptodev-linux:"

SRC_URI += "file://0001-add-support-for-RSA-public-and-private-key-operation.patch"
