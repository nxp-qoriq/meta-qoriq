SRC_URI = "git://bitbucket.sw.nxp.com/sdk/cst;protocol=ssh;nobranch=1"
SRCREV = "715934d06b5a1a16742ef405cb0378f4c9df1529"
