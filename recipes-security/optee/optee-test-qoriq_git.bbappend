DEPENDS += "python3-pycryptodome-native"
DEPENDS_remove = "python3-pycrypto-native"

SRC_URI = "git://bitbucket.sw.nxp.com/dash/optee_test.git;protocol=ssh;nobranch=1"
SRCREV = "30481e381cb4285706e7516853495a7699c93b2c"
