IMAGE_INSTALL:append = " flex-installer"
IMAGE_INSTALL:remove = " udev-extraconf"
IMAGE_INSTALL:append = " zstd"
