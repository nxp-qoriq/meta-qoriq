LICENSE = "GPL-2.0-only"
INSANE_SKIP:${PN}-dbg += " buildpaths"
