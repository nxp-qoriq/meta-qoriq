SRC_URI = "git://github.com/nxp-qoriq/spc;protocol=https;nobranch=1"
