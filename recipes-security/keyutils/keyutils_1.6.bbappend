FILES_${PN} += "/lib/pkgconfig/*.pc"
