require optee-client.nxp.inc

PV_append = "+git${SRCPV}"

COMPATIBLE_MACHINE = "(qoriq-arm64)"
