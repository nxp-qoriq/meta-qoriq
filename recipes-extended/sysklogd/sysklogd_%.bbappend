FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SECURITY_NOPIE_CFLAGS_qoriq-ppc = ""
