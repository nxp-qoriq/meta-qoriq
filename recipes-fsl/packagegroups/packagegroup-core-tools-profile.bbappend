# Disable perf as it has build break based on k5.5
RRECOMMENDS_${PN}_remove = "perf"
