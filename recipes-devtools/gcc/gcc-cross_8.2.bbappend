EXTRA_OECONF_append_e500v2 = " --enable-obsolete"
