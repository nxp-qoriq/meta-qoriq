require gcc-${PV}.inc
require recipes-devtools/gcc/gcc-runtime.inc

