LIC_FILES_CHKSUM = "file://COPYING;md5=47716bd5b656aa5e298a132a64d2d1e4"

SRC_URI = "git://bitbucket.sw.nxp.com/scm/dash/eth-config.git;protocol=https;nobranch=1"
SRCREV = "eefb06353c8c3db34d22c26825b66e921bce617d"
