DEPENDS += "p11-kit"

PACKAGECONFIG = "libidn p11-kit"
