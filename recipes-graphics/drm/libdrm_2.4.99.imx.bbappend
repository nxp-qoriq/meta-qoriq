IMX_LIBDRM_SRC = "git://bitbucket.sw.nxp.com/gtec/libdrm-imx.git;protocol=ssh;nobranch=1"

