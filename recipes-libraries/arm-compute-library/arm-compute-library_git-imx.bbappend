PACKAGECONFIG_OPENCL_qoriq-arm64  = " " 

COMPATIBLE_MACHINE = "(mx8|qoriq-arm64)"
