PACKAGECONFIG_append_qoriq-arm64 = " numactl"

