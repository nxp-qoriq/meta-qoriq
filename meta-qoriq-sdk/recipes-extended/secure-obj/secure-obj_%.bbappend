# Copyright 2022-2024 NXP

INSANE_SKIP:${PN}-dbg += " buildpaths"
INSANE_SKIP:${PN} += " buildpaths"
