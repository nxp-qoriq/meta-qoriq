PACKAGECONFIG_append_qoriq-arm64  = " dnn text"
