SRC_URI = "git://github.com/openil/tsntool;nobranch=1"
SRCREV = "b74987c855fb5605d2e384d355d101c68c4d6eaf"

