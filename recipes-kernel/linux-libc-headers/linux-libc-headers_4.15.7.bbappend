do_install_armmultilib_append () {
        oe_multilib_header asm/bpf_perf_event.h asm/kvm_para.h
}

