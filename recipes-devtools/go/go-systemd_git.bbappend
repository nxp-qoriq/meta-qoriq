SRC_URI = "git://${PKG_NAME}.git;nobranch=1"
