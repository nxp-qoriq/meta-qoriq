FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-add-support-for-RSA-public-and-private-key-operation.patch \
	    file://0001-Fix-build-for-Linux-6.7.patch"
