SRCREV = "5b9f4b16a864e9dfa58cdcc860be278a7f66ac18"

SRC_URI:remove = "file://0001-FMCCFGReader-improve-parameter-definition-of-functio.patch"
