# Override default mesa drivers with i.MX GPU drivers
RRECOMMENDS:${PN}:ls1028ardb = "libvulkan-imx"
