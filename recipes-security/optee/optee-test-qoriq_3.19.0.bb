# Copyright (C) 2022 NXP
require optee-test.nxp.inc

OPTEE_TEST_BRANCH = "lf-5.15.71_2.2.0"
PV:append = "+git${SRCPV}"
