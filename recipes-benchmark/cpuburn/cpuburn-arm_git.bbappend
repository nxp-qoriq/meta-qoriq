COMPATIBLE_MACHINE_ls1021atwr = "(ls1021atwr)"
