# Copyright (C) 2022 NXP
require optee-test.nxp.inc

OPTEE_TEST_BRANCH = "lf_3.17.y"
PV:append = "+git${SRCPV}"
