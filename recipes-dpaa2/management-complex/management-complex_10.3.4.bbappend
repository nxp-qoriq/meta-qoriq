LICENSE = "Freescale-Binary-EULA"
LIC_FILES_CHKSUM = "file://NXP-Binary-EULA.txt;md5=13ce64aed5343d34883aa6b002f8994d"

SRC_URI = "git://github.com/NXP/qoriq-mc-binary.git;protocol=https;nobranch=1"

SRCREV = "40b0c8b7edfd2d8f989619b12d6352472455c696"
