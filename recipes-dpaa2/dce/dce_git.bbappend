SRC_URI = "git://bitbucket.sw.nxp.com/dpaa2/dce.git;protocol=ssh;nobranch=1"
SRCREV = "ede610bba89bce2790d66044faf091720e2d1cb0"
SRC_URI = "git://bitbucket.sw.nxp.com/dpaa2/dce.git;protocol=ssh;nobranch=1 \
      git://bitbucket.sw.nxp.com/dpaa2/qbman_userspace.git;protocol=ssh;nobranch=1;name=qbman;destsuffix=git/lib/qbman_userspace \
"
SRCREV_qbman = "a1af1e1528fe2e1ce0df1e6d9170b6c239c8ab4f"

