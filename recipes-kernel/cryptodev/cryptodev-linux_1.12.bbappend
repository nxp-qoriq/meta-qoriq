FILESEXTRAPATHS:prepend := "${THISDIR}/cryptodev-module:"

SRC_URI += "file://0001-Fix-build-for-Linux-6.3-rc1.patch"
