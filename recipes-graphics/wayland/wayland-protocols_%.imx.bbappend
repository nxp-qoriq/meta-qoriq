COMPATIBLE_MACHINE = "(imx-nxp-bsp|qoriq)"
