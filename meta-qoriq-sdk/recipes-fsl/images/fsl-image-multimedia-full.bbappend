PACKAGE_IMX_TO_REMOVE:qoriq-arm64 = "clutter-1.0-examples"
CORE_IMAGE_EXTRA_INSTALL += " \
    packagegroup-core-ssh-openssh \
    packagegroup-fsl-mfgtools \
    libopencl-imx \
    imx-gpu-viv-demos \
"
