# Copyright 2022-2023 NXP
require optee-os.nxp.inc

OPTEE_OS_BRANCH = "lf-6.1.1_1.0.0"
PV:append = "+git${SRCPV}"
