EXTRA_OECONF_append = " --enable-rsh --enable-rshd "
