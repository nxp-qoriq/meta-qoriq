# Copyright (C) 2022 NXP
require optee-client.nxp.inc

OPTEE_CLIENT_BRANCH = "lf_3.17.y"
PV:append = "+git${SRCPV}"
